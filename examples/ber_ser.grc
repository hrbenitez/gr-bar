<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ber_ser</value></param>
<param><key>category</key><value>[bar]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>BER / SER</value></param>
</block>
<block>
<key>bar_out_sync</key>
<param><key>id</key><value>bar_out_sync_0</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>window</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0</value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>type</key><value>'SER'</value></param>
<param><key>win_size</key><value>window</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>BER</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>SER</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>bits_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>symb_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0_0</value></param>
<param><key>label</key><value>sync_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0_0_0</value></param>
<param><key>label</key><value>sync_ref</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0_1</value></param>
<param><key>label</key><value>symb_ref</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_1</value></param>
<param><key>label</key><value>bits_ref</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>window</value></param>
<param><key>label</key><value>Window</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2**20)</value></param>
</block>
<connection><source_block_id>bar_out_sync_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bar_out_sync_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>bar_out_sync_0</source_block_id><sink_block_id>blks2_error_rate_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bar_out_sync_0</source_block_id><sink_block_id>blks2_error_rate_0_0</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>bar_out_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>bar_out_sync_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0_0</source_block_id><sink_block_id>bar_out_sync_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0_0_0</source_block_id><sink_block_id>bar_out_sync_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0_1</source_block_id><sink_block_id>bar_out_sync_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pad_source_0_0_1</source_block_id><sink_block_id>bar_out_sync_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
</flow_graph>
